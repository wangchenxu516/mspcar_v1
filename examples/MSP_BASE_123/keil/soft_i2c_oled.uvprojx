# Keil uVision project soft_i2c_oled.uvprojx, settings and files
target soft_i2c_oled (6210000::V6.21::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ncontroller +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..\..\..\source\third_party\CMSIS\Core\Include;..\..\..\source;..\;..\ndrivers;..\user_c;..\user_h
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group Source
    ../../../source/ti/driverlib/: dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_i2c.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc_common.c dl_spi.c dl_timer.c dl_trng.c dl_uart.c dl_vref.c
    ../../../source/ti/driverlib/m0p/: dl_interrupt.c
    ../../../source/ti/driverlib/m0p/sysctl/: dl_sysctl_mspm0g1x0x_g3x0x.c dl_sysctl_mspm0g1x0x_g3x0x.h
  group ndriver
    ../ndrivers/: drv_oled.c glcdfont.c ssd1306.c usart0.h usart0.c usart1.c usart1.h
    ../../../../04_MSPM0G3507/examples/MSP_BASE_123/ndrivers/: jy61p.c jy61p.h usart3.c usart3.h
  group User
    ../: main.c ncontroller.syscfg ti_msp_dl_config.c ti_msp_dl_config.h
    ./: startup_mspm0g350x_uvision.s
    ../user_h/: head.h
  group user_c
    ../user_c/: Key.c HUIDU.c motor.c mode.c timer.c Delay.c board.c PWM_SG90.c bsp_mpu6050.c PID.c Encoder.c mpucal.c
    ./: PIN.txt
  group user_h
    ../user_h/: HUIDU.h Encoder.h motor.h timer.h PID.h mode.h Delay.h Key.h board.h PWM_SG90.h bsp_mpu6050.h mpucal.h
